# Keil uVision project Motion_Controller.uvprojx, settings and files
target Motion_Controller (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Machanical_Dynamic_Matrix +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Drivers\Custom\Bsp;..\Middlewares\Custom;..\Applications\Custom;..\Middlewares\Third_Party\Tracealyzer\include;..\Middlewares\Third_Party\Tracealyzer\config;..\Middlewares\Third_Party\Tracealyzer\Jlink_RTT\include
  asm include: ..\\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c adc.c freertos.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c fifo.c sdio.c dma.c
  group Application/Custom
    ../Applications/Custom/: algorithm.c Global.c UI.c drive_port_test.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/Third_Party/Tracealyzer/Source_File
    ../Middlewares/Third_Party/Tracealyzer/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
  group Middlewares/Third_Party/Tracealyzer/Config
    ../Middlewares/Third_Party/Tracealyzer/config/: trcConfig.h trcSnapshotConfig.h trcStreamingConfig.h
  group Middlewares/Third_Party/Tracealyzer/Include
    ../Middlewares/Third_Party/Tracealyzer/include/: aws_secure_sockets.tzext.h aws_wifi.tzext.h trcExtensions.h trcHardwarePort.h trcKernelPort.h trcPortDefines.h trcRecorder.h
  group Middlewares/Third_Party/Tracealyzer/Jlink_RTT
    ../Middlewares/Third_Party/Tracealyzer/Jlink_RTT/: SEGGER_RTT.c trcStreamingPort.c
  group Middlewares/Custom
    ../Middlewares/Custom/: coupling_between_app_and_bsp.c datastruct.c factory_setting.c gbk_font_matrix.c version_manage.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_sd.c stm32f1xx_ll_sdmmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/Custom/Bsp
    ../Drivers/Custom/Bsp/: LCD12864.c printf.c Rs485.c pin_remap.h key.c SDcard.c
software components: CMSIS:CORE 5.2.0
